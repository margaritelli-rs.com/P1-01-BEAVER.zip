Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [ContentGUID: , VersionGUID: 4bcdf7e2-fbb6-4bca-94d0-dd898c7c3723, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordinate condivise]
File name: P1-01 BEAVER DOWNSTREAM.ifc
Time: 2025-10-19T13:12:13+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ITA) - IFC 23.4.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto

# IfcBuildingStorey: Livello:Livello 1, Livello 1
LongName: Livello 1; Elevation: 0 mm
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello 1; ID tipo: 1899; Tipo: Livello 1
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: Livello 1; Piano edificio: yes; Strutturale: no
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Solido; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello 1

# IfcRailing: P1-01 BEAVER DOWNSTREAM_R23:P1-01 BEAVER DOWNSTREAM_R23, P1-01 BEAVER DOWNSTREAM_R23:P1-01 BEAVER DOWNSTREAM_R23:6950
In: Livello 1
Type - Material: Metal, wood, White, <Unnamed>
Type - Altro - Categoria: Ringhiere: Supporti; Nome famiglia: P1-01 BEAVER DOWNSTREAM_R23
Type - Costruzione - Altezza: 125 mm
Type - Dati identità - Acciaio CAM Strade: conforme; ASI: 0,8; certificazione: crash test; classe: P1; Classe box uscita: Z2; Connessione: N2BL-01; Costo: 6962.5; Descrizione: (colore); EPD: sì; GWP totale cradle to gate: 75,3 kgCO2eq/m; installazione: Fondazione; Legno CAM Strade: CoC PEFC; Livello di severità: A; materiale: Acciaio S355J0WP e Legno lamellare GL24H; Modello: P1-01 BEAVER downstream; Nome del tipo: P1-01 BEAVER DOWNSTREAM_R23; norma di riferimento: ENV 1317-4; prezzo di capitolato: 6962.5; prodotto: Terminale certificato; Produttore: Margaritelli Road Safety; tipologia: Chiusura; unità di misura: N; URL: https://margaritelli-rs.com/it/products/p1-01_beaver/; url (short report, manuali, schede tecniche, schemi): https://margaritelli-rs.com/it/products/p1-01_beaver/
Type - Pset_ManufacturerTypeInformation - Manufacturer: Margaritelli Road Safety
Pset_QuantityTakeOff - Reference: P1-01 BEAVER DOWNSTREAM_R23
Pset_RailingCommon - Reference: P1-01 BEAVER DOWNSTREAM_R23; IsExternal: no
Altro - Famiglia: P1-01 BEAVER DOWNSTREAM_R23; Famiglia e tipo: P1-01 BEAVER DOWNSTREAM_R23: P1-01 BEAVER DOWNSTREAM_R23; ID tipo: 6934; Tipo: P1-01 BEAVER DOWNSTREAM_R23
Vincoli - Gioco mano: 0 mm; Host: Livello : Livello 1; Livello: Livello 1; Offset da host: 0 mm; Sposta con gli elementi più vicini: no
Quote - Area: 10.0567 m2; Volume: 0.17789 m3
